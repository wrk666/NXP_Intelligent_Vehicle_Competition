# IAR project Backup (2) of KEA128.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; S9KEAZ1284
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA128.srec
  ILINK.IlinkOutputFile: KEA128.out
  ILINK.IlinkIcfFile: KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Control
    ../../../Libraries/drives/src/: Balance.c PID.c PWM.c
    ../../../Libraries/drives/inc/: Balance.h
  group drives/inc
    ../../../Libraries/drives/inc/: common.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h
  group drives/src
    ../../../Libraries/drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c
  group Scope
    ../../../Libraries/drives/src/: ANO_TC.c Scope.c
  group seekfree
    ../../../Libraries/seekfree/: font.c font.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group Sensor
    ../../../Libraries/drives/src/: Attitude_Calculate.c FXAS2100.c FXOS8700.c Soft_IIC.c Tracking_Sensor.c
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_SKEAZ1284.s
    ../../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c system_SKEAZ1284.h
  group UI
    ../../../Libraries/drives/src/: Keyboard.c OLED.c
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/: version.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
